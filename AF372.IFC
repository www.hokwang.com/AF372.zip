Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: AF372.IFC
Time: 2022-01-06T03:40:07
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 3437-35_1
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 370-02_1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 370-04_1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 370-05_1
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 370-10_1
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 372-01
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 376-02_1
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 376-03_1
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: P44_1
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
